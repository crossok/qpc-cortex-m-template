# Keil uVision project qpc-cortex-m.uvprojx, settings and files
target qpc-cortex-m (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F051C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: qpc-cortex-m
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER STM32F051x8
  c include: ..;../include;../include/qm;../include/port;../include/hal;../third_party/qpc/src;../third_party/qpc/include;../third_party/qpc/ports/arm-cm/qv/arm;../third_party/SEGGER_RTT/RTT;../third_party/STM32Cube_FW_F0/Drivers/STM32F0xx_HAL_Driver/Inc;../third_party/STM32Cube_FW_F0/Drivers/CMSIS/Device/ST/STM32F0xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group qm
    ../src/qm/: qm_main.c qm_power.c qm_led.c
  group base
    ../src/base/: bsp.c cpu.c delay.c gpio.c uart.c led.c
  group qpc
    ../third_party/qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../third_party/qpc/src/qv/: qv.c
    ../third_party/qpc/ports/arm-cm/qv/arm/: qv_port.c
  group st
    ../third_party/STM32Cube_FW_F0/Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group device
    ../third_party/STM32Cube_FW_F0/Drivers/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f051x8.s
  group hal
    ../src/hal/: usart.c gpio.c main.c stm32f0xx_hal_msp.c system_stm32f0xx.c stm32f0xx_it.c
  group RTT
    ../third_party/SEGGER_RTT/RTT/: SEGGER_RTT_printf.c SEGGER_RTT.c
software components: CMSIS:CORE 5.0.1
